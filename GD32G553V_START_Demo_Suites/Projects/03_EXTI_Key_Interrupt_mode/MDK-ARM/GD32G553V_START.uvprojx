# Keil uVision project GD32G553V_START.uvprojx, settings and files
target GD32G553V_START (6130001::V6.13.1::.\ARMCLANG)
  device: GD32G553VE GigaDevice
  pack: GigaDevice.GD32G5x3_DFP.1.2.0
  cpu: IRAM(0x20000000,0x18000) IRAM2(0x10000000,0x8000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32G553
  c include: ..\..\..\..\GD32G5x3_Firmware_Library\CMSIS\GD\GD32G5x3\Include;..\..\..\..\GD32G5x3_Firmware_Library\GD32G5x3_standard_peripheral\Include;..\..\..\Utilities;..\;..\..\..\..\GD32G5x3_Firmware_Library\CMSIS\GD\GD32G5x3\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application
    ../: gd32g5x3_it.c main.c systick.c
  group CMSIS
    ../../../../GD32G5x3_Firmware_Library/CMSIS/GD/GD32G5x3/Source/: system_gd32g5x3.c
  group GD32G5x3_Peripherals
    ../../../../GD32G5x3_Firmware_Library/GD32G5x3_standard_peripheral/Source/: gd32g5x3_adc.c gd32g5x3_can.c gd32g5x3_cau.c gd32g5x3_cau_aes.c gd32g5x3_cau_des.c gd32g5x3_cau_tdes.c gd32g5x3_cla.c gd32g5x3_cmp.c gd32g5x3_cpdm.c gd32g5x3_crc.c gd32g5x3_dac.c gd32g5x3_dbg.c gd32g5x3_dma.c gd32g5x3_exmc.c gd32g5x3_exti.c gd32g5x3_fac.c gd32g5x3_fft.c gd32g5x3_fmc.c gd32g5x3_fmc_ramfunc.c gd32g5x3_fwdgt.c gd32g5x3_gpio.c gd32g5x3_hpdf.c gd32g5x3_i2c.c gd32g5x3_lptimer.c gd32g5x3_misc.c gd32g5x3_pmu.c gd32g5x3_qspi.c gd32g5x3_rcu.c gd32g5x3_rtc.c gd32g5x3_hrtimer.c gd32g5x3_spi.c gd32g5x3_syscfg.c gd32g5x3_timer.c gd32g5x3_tmu.c gd32g5x3_trigsel.c gd32g5x3_trng.c gd32g5x3_usart.c gd32g5x3_vref.c gd32g5x3_wwdgt.c
  group GD32G5x3_START
    ../../../Utilities/: gd32g553v_start.c
  group Startup
    ../../../../GD32G5x3_Firmware_Library/CMSIS/GD/GD32G5x3/Source/ARM/: startup_gd32g5x3.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
